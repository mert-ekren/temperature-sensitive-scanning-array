# Keil uVision project proje447.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proje447
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: DELAY200.s OutStr.s CheckPB6.s DELAY100.s READ.s DELAY2s.s project_step1.c Nokia5110.c Nokia5110.h valvtm4c123gh6pm.h I2C0.c I2C0.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
